SUMMARY = "Summit firmware for the LWB5 SDIO/UART module"

require radio-firmware-lwb.inc
