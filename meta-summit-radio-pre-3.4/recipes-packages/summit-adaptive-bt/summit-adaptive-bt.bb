SUMMARY = "Summit Bluetooth 60 Auto World-Wide Mode"

require summit-adaptive-bt.inc
require radio-stack-version.inc
