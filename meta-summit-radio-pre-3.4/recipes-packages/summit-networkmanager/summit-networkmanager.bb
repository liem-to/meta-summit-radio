SUMMARY = "Summit Network Manager"

require summit-networkmanager.inc
require radio-stack-version.inc
