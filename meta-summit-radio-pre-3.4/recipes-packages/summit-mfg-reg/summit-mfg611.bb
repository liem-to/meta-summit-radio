SUMMARY = "Summit Wi-Fi NX611 Manufacturing tools"

REG_NAME = "mfg611"

require mfg-reg.inc
require radio-stack-version.inc
