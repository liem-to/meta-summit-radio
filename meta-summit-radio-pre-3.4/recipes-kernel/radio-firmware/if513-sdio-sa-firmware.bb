SUMMARY = "Summit firmware for the IF513 SDIO/UART module with single antenna"

require radio-firmware-lwb.inc
