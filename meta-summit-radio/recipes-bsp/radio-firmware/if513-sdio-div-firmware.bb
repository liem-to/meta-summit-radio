SUMMARY = "Summit firmware for the IF513 SDIO/UART module with diversity antenna"

require radio-firmware-lwb.inc
