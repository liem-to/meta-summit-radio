SUMMARY = "Firmware for the Sona NX611 1218 with integrated antennas module"

SONA_NX_PKG_PREFIX ?= "1218"

require radio-firmware-nx.inc
