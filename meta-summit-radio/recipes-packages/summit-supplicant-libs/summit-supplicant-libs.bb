SUMMARY = "Wi-Fi Summit Supplicant Libraries"

require summit-supplicant-libs.inc
require radio-stack-version.inc
