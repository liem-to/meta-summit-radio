SUMMARY = "Summit hostapd"

require summit-hostapd.inc
require radio-stack-version.inc
