SUMMARY = "Summit Supplicant"

require summit-supplicant-modern.inc
require radio-stack-version.inc
