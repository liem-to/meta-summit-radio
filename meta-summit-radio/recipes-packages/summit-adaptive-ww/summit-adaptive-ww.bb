require summit-adaptive-ww.inc
require radio-stack-version.inc
